# Keil uVision project ttrd_eres02.uvprojx, settings and files
target STM32F407VGTx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TTRD-ERES2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_FULL_ASSERT USE_STDPERIPH_DRIVER HSE_VALUE=8000000 CORTEX
  c include: ..\source\hsi_library; ..\source\hsi_startup
  asm define: CORTEX
  asm include: ..\source\startup;..\source\cora\hwt\inc;..\source\cora\hwt\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group hsi_library
    ../source/hsi_library/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h misc.c misc.h stm32f4xx.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_conf.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h
  group hsi_startup
    ../source/hsi_startup/: ttrd2-19a-t0401a-v001a_assert_failed.c startup_stm32f407xx.s system_stm32f4xx.c system_stm32f4xx.h
  group main
    ../source/main/: main.c main.h
  group port
    ../source/port/: port.h
  group processor
    ../source/processor/: ttrd2-a08a-t0401a-v001a_processor.c ttrd2-a08a-t0401a-v001a_processor.h
  group scheduler
    ../source/scheduler/: ttrd2-a08a-t0401a-v001a_dry_scheduler.c ttrd2-a08a-t0401a-v001a_dry_scheduler.h
  group support_functions
    ../source/support_functions/: ttrd2-a08a-t0401a-v001a_uart2_unbuff_o.c ttrd2-a08a-t0401a-v001a_uart2_unbuff_o.h
  group tasks
    ../source/tasks/: ttrd2-a08a-t0401a-v001a_dummy_task.c ttrd2-a08a-t0401a-v001a_dummy_task.h
