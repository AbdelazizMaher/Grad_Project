# Keil uVision project ttrd_eres02.uvprojx, settings and files
target STM32F407VGTx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TTRD-ERES2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_FULL_ASSERT USE_STDPERIPH_DRIVER HSE_VALUE=8000000 CORTEX
  c include: ..\source\hsi_library; ..\source\hsi_startup
  asm define: CORTEX
  asm include: ..\source\startup;..\source\cora\hwt\inc;..\source\cora\hwt\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group hsi_library
    ../source/hsi_library/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_fsmc.c stm32f4xx_fsmc.h misc.h
  group hsi_reg_config_checks
    ../source/hsi_reg_config_checks/: ttrd2-05a-t0401a-v001a_reg_conf_chk_adc1.c ttrd2-05a-t0401a-v001a_reg_conf_chk_adc1.h ttrd2-05a-t0401a-v001a_reg_conf_chk_gpio.c ttrd2-05a-t0401a-v001a_reg_conf_chk_gpio.h ttrd2-05a-t0401a-v001a_reg_conf_chk_timer.c ttrd2-05a-t0401a-v001a_reg_conf_chk_timer.h ttrd2-05a-t0401a-v001a_reg_conf_chk_uart.c ttrd2-05a-t0401a-v001a_reg_conf_chk_uart.h
  group hsi_startup
    ../source/hsi_startup/: system_stm32f4xx.c ttrd2-19a-t0401a-v001a_assert_failed.c startup_stm32f407xx.s system_stm32f4xx.h
  group main
    ../source/main/: main.c main.h
  group port
    ../source/port/: port.h
  group processor
    ../source/processor/: ttrd2-04a-t0401a-v001a_pfc_reporting.c ttrd2-04a-t0401a-v001a_pfc_reporting.h ttrd2-19a-t0401a-v001b_run_time_tests.c ttrd2-19a-t0401a-v001b_run_time_tests.h ttrd2-a07a-t0401a-v001b_processor.c ttrd2-a07a-t0401a-v001b_processor.h
  group scheduler
    ../source/scheduler/: ttrd2-18a-t0401a-v001a_monittor_i.c ttrd2-18a-t0401a-v001a_monittor_i.h ttrd2-19a-t0401a-v001b_predicttor_i.c ttrd2-19a-t0401a-v001b_predicttor_i.h ttrd2-19a-t0401a-v001b_predicttor_i_tick_list.h ttrd2-a07a-t0401a-v001a_instrumented_scheduler.c ttrd2-a07a-t0401a-v001a_instrumented_scheduler.h ttrd2-a07a-t0401a-v001a_measure_t4.c ttrd2-a07a-t0401a-v001a_measure_t4.h ttrd2-a07a-t0401a-v001a_measure_t5.c ttrd2-a07a-t0401a-v001a_measure_t5.h
  group support_functions
    ../source/support_functions/: ttrd2-05a-t0401a-v001a_timeout_t3.c ttrd2-05a-t0401a-v001a_timeout_t3.h
  group tasks
    ../source/tasks/: ttrd2-05a-t0401a-v001a_adc_task.c ttrd2-05a-t0401a-v001a_adc_task.h ttrd2-05a-t0401a-v001a_heartbeat_sw_task.c ttrd2-05a-t0401a-v001a_heartbeat_sw_task.h ttrd2-05a-t0401a-v001a_iwdt_task.c ttrd2-05a-t0401a-v001a_iwdt_task.h ttrd2-05a-t0401a-v001a_switch_task.c ttrd2-05a-t0401a-v001a_switch_task.h ttrd2-05a-t0401a-v001a_uart2_buff_o_task.c ttrd2-05a-t0401a-v001a_uart2_buff_o_task.h ttrd2-19a-t0401a-v001b_processor_task.c ttrd2-19a-t0401a-v001b_processor_task.h
  group ecss_services
    ../source/ecss_services/: ecss_stats.c ecss_stats.h event_reporting_service.c event_reporting_service.h hldlc.c hldlc.h housekeeping.c housekeeping.h housekeeping_service.c housekeeping_service.h mass_storage_service.c mass_storage_service.h mxconstants.h obc.c obc.h obc_hsi.c obc_hsi.h pkt_pool.c pkt_pool.h power_ctrl.c power_ctrl.h queue.c queue.h scheduling_service.c scheduling_service.h service_utilities.c service_utilities.h services.c services.h subsystems_ids.h system.h test_service.c test_service.h time_management_service.c time_management_service.h uart_hal.c uart_hal.h upsat.c upsat.h verification_service.c verification_service.h
